# IAR project BLUENRG-X.ewp, settings and files
configuration BlueNRG-1 (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCIncludePath2: inc; $TOOLKIT_DIR$\src\flashloader\framework2; $TOOLKIT_DIR$\CMSIS\Include
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BLUENRG-1.srec
  ILINK.IlinkOutputFile: BlueNRG-1.out
  ILINK.IlinkIcfFile: FlashBLUENRG-1_24kB.icf
  ILINK.IlinkProgramEntryLabel: FlashEraseWriteEntry
configuration BlueNRG-2 (ARM, debug)
  as the first configuration, except:
configuration BlueNRG-345 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BLUENRG_3
  OBJCOPY.OOCOutputFile: BLUENRG-345.srec
  ILINK.IlinkOutputFile: BlueNRG-345.out
  ILINK.IlinkIcfFile: FlashBLUENRG-345_32kB.icf
configuration BlueNRG-355 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BLUENRG_3
  OBJCOPY.OOCOutputFile: BLUENRG-355.srec
  ILINK.IlinkOutputFile: BlueNRG-355.out
  ILINK.IlinkIcfFile: FlashBLUENRG-355_64kB.icf
  group framework
    Sources/Library_Files/: Flash_BlueNRG-X.c
    $EW_DIR$/arm/src/flashloader/framework2/: flash_loader.c flash_loader_asm.s
