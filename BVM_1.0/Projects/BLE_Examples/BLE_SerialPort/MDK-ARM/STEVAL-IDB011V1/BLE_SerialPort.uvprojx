# Keil uVision project BLE_SerialPort.uvprojx, settings and files
target Client (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: BlueNRG-355 STMicroelectronics
  pack: Keil.STBlueNRG-LP_DFP.3.0.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x10040000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: BLE_SerialPort_Client +hex
  AfterMake: fromelf.exe --bin Client\Objects\BLE_SerialPort_Client.axf --output Client\Objects\BLE_SerialPort_Client.bin
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_FULL_LL_DRIVER STEVAL_IDB011V1 CLIENT=1 CONFIG_DEVICE_BLUENRG_LP CONFIG_HW_SMPS_10uH CONFIG_HW_HSE_TUNE=38 USER_BUTTON=BSP_PUSH1 CONFIG_HW_LS_RO BLE_STACK_CUSTOM_CONF
  c include: ..\..\Inc;..\..\..\..\..\Drivers\Peripherals_Drivers\Inc;..\..\..\..\..\Drivers\CMSIS\Device\ST\BlueNRG_LP\Include;..\..\..\..\..\Middlewares\ST\hal\Inc;..\..\..\..\..\Middlewares\ST\PKAMGR\Inc;..\..\..\..\..\Middlewares\ST\RNGMGR\Inc;..\..\..\..\..\Middlewares\ST\AESMGR\Inc;..\..\..\..\..\Middlewares\ST\BLECNTR\Inc;..\..\..\..\..\Middlewares\ST\NVMDB\Inc;..\..\..\..\..\Drivers\CMSIS\Include;../../../../../Drivers/BSP/STEVAL-IDB011V1/Inc;..\..\..\..\..\Drivers\BSP\Common\Inc;..\..\..\..\..\Drivers\BSP\Components\lps22hh_STdC\driver;..\..\..\..\..\Drivers\BSP\Components\lsm6dsox_STdC\driver;..\..\..\..\..\Middlewares\ST\BLE_Application\layers_inc;..\..\..\..\..\Middlewares\ST\BLE_Application\OTA\inc;..\..\..\..\..\Middlewares\ST\Bluetooth_LE\Inc;..\..\..\..\..\Middlewares\ST\NVMDB\Inc;..\..\..\..\..\Middlewares\ST\BLE_Application\Profiles\Inc;..\..\..\..\..\Middlewares\ST\cryptolib\inc;..\..\..\..\..\Middlewares\ST\cryptolib\inc\Common;..\..\..\..\..\Middlewares\ST\cryptolib\inc\AES
  asm misc: --cpreproc
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: BlueNRG_LP.sct
  group Drivers/BSP
    ../../../../../Drivers/BSP/STEVAL-IDB011V1/Src/: bluenrg_lp_evb_button.c bluenrg_lp_evb_io.c bluenrg_lp_evb_led.c
    ../../../../../Drivers/BSP/Components/lps22hh_STdC/driver/: lps22hh_reg.c
    ../../../../../Drivers/BSP/Components/lsm6dsox_STdC/driver/: lsm6dsox_reg.c
  group Drivers/CMSIS
    ../../../../../Drivers/CMSIS/Device/ST/BlueNRG_LP/Source/: system_BlueNRG_LP.c
  group Drivers/Peripherals_Drivers
    ../../../../../Drivers/Peripherals_Drivers/src/: rf_driver_hal_power_manager.c rf_driver_hal_vtimer.c rf_driver_ll_adc.c rf_driver_ll_crc.c rf_driver_ll_dma.c rf_driver_ll_exti.c rf_driver_ll_flash.c rf_driver_ll_gpio.c rf_driver_ll_lpuart.c rf_driver_ll_pka_v7b.c rf_driver_ll_pwr.c rf_driver_ll_radio_2g4.c rf_driver_ll_rcc.c rf_driver_ll_rng.c rf_driver_ll_spi.c rf_driver_ll_tim.c rf_driver_ll_timer.c rf_driver_ll_rtc.c rf_driver_ll_usart.c rf_driver_ll_utils.c
  group Example/User
    ../../Src/: BLE_SerialPort_main.c bluenrg_lp_it.c gatt_db.c serial_port.c configuration.c key.c uart.c dsp.c
  group Middlewares/AES
    ../../../../../Middlewares/ST/AESMGR/Src/: aes_manager_bluenrg_lp.c
  group Middlewares/BLE_Stack
    ../../../../../Middlewares/ST/Bluetooth_LE/Library/: libbluenrg_lp_stack.a
    ../../../../../Middlewares/ST/Bluetooth_LE/Src/: stack_user_cfg.c
  group Middlewares/BLECNTR
    ../../../../../Middlewares/ST/BLECNTR/Src/: ble_controller.c ble_controller_bluenrg_lp.c
  group Middlewares/Cryptolib
    ../../../../../Middlewares/ST/cryptolib/: aes_hw.c libcrypto.a
  group Middlewares/Hal
    ../../../../../Middlewares/ST/hal/Src/: blue_unit_conversion.s clock.c context_switch.s fifo.c gp_timer.c hal_miscutil.c miscutil.c osal.c osal_memcpy.s
  group Middlewares/NVM
    ../../../../../Middlewares/ST/NVMDB/Src/: nvm_db.c nvm_db_conf.c nvm_db_upper_layer.c
  group Middlewares/OTA
    ../../../../../Middlewares/ST/BLE_Application/OTA/Src/: OTA_btl.c
  group Middlewares/PKA
    ../../../../../Middlewares/ST/PKAMGR/Src/: pka_manager.c pka_manager_bluenrg_lp.c
  group Middlewares/Profiles
    ../../../../../Middlewares/ST/BLE_Application/Profiles/Src/: gap_profile.c gatt_profile.c
  group Middlewares/RNG
    ../../../../../Middlewares/ST/RNGMGR/Src/: rng_manager.c rng_manager_bluenrg_lp.c
target Server (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: BlueNRG-355 STMicroelectronics
  pack: Keil.STBlueNRG-LP_DFP.3.0.0
  cpu: as above
  output: BLE_SerialPort_Server +hex
  AfterMake: fromelf.exe --bin Server\Objects\BLE_SerialPort_Server.axf --output Server\Objects\BLE_SerialPort_Server.bin
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_FULL_LL_DRIVER STEVAL_IDB011V1 SERVER=1 CONFIG_DEVICE_BLUENRG_LP CONFIG_HW_SMPS_10uH CONFIG_HW_HSE_TUNE=38 USER_BUTTON=BSP_PUSH1 CONFIG_HW_LS_RO BLE_STACK_BASIC_CONF
  c include: ..\..\Inc;..\..\..\..\..\Drivers\Peripherals_Drivers\Inc;..\..\..\..\..\Drivers\CMSIS\Device\ST\BlueNRG_LP\Include;..\..\..\..\..\Middlewares\ST\hal\Inc;..\..\..\..\..\Middlewares\ST\PKAMGR\Inc;..\..\..\..\..\Middlewares\ST\RNGMGR\Inc;..\..\..\..\..\Middlewares\ST\AESMGR\Inc;..\..\..\..\..\Middlewares\ST\BLECNTR\Inc;..\..\..\..\..\Drivers\CMSIS\Include;../../../../../Drivers/BSP/STEVAL-IDB011V1/Inc;..\..\..\..\..\Drivers\BSP\Common\Inc;..\..\..\..\..\Drivers\BSP\Components\lps22hh_STdC\driver;..\..\..\..\..\Drivers\BSP\Components\lsm6dsox_STdC\driver;..\..\..\..\..\Middlewares\ST\BLE_Application\layers_inc;..\..\..\..\..\Middlewares\ST\BLE_Application\OTA\inc;..\..\..\..\..\Middlewares\ST\Bluetooth_LE\Inc;..\..\..\..\..\Middlewares\ST\NVMDB\Inc;..\..\..\..\..\Middlewares\ST\BLE_Application\Profiles\Inc;..\..\..\..\..\Middlewares\ST\cryptolib\inc;..\..\..\..\..\Middlewares\ST\cryptolib\inc\Common;..\..\..\..\..\Middlewares\ST\cryptolib\inc\AES
  asm misc: --cpreproc
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: BlueNRG_LP.sct
target Server_LowerApp_OTA (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: BlueNRG-355 STMicroelectronics
  pack: Keil.STBlueNRG-LP_DFP.3.0.0
  cpu: as above
  output: BLE_SerialPort_Server_LowerApp_OTA +hex
  AfterMake: fromelf.exe --bin Server_LowerApp_OTA\Objects\BLE_SerialPort_Server_LowerApp_OTA.axf --output Server_LowerApp_OTA\Objects\BLE_SerialPort_Server_LowerApp_OTA.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: USE_FULL_LL_DRIVER STEVAL_IDB011V1 SERVER=1 CONFIG_DEVICE_BLUENRG_LP CONFIG_HW_SMPS_10uH CONFIG_HW_HSE_TUNE=32 USER_BUTTON=BSP_PUSH1 CONFIG_OTA_LOWER CONFIG_HW_LS_XTAL BLE_STACK_SLAVE_DLE_CONF CONFIG_SW_OTA_DATA_LENGTH_EXT
  c include: as above
  asm misc: --cpreproc
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: BlueNRG_LP.sct
  link misc: --predefine="-DCONFIG_OTA_LOWER=1 "
target Server_HigherApp_OTA (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: BlueNRG-355 STMicroelectronics
  pack: Keil.STBlueNRG-LP_DFP.3.0.0
  cpu: as above
  output: BLE_SerialPort_Server_HigherApp_OTA +hex
  AfterMake: fromelf.exe --bin Server_HigherApp_OTA\Objects\BLE_SerialPort_Server_HigherApp_OTA.axf --output Server_HigherApp_OTA\Objects\BLE_SerialPort_Server_HigherApp_OTA.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: USE_FULL_LL_DRIVER STEVAL_IDB011V1 SERVER=1 CONFIG_DEVICE_BLUENRG_LP CONFIG_HW_SMPS_10uH CONFIG_HW_HSE_TUNE=32 USER_BUTTON=BSP_PUSH1 CONFIG_OTA_HIGHER CONFIG_HW_LS_XTAL BLE_STACK_SLAVE_DLE_CONF CONFIG_SW_OTA_DATA_LENGTH_EXT
  c include: as above
  asm misc: --cpreproc
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: BlueNRG_LP.sct
  link misc: --predefine="-DCONFIG_OTA_HIGHER=1 "
target Server_Use_OTA_ServiceManager (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: BlueNRG-355 STMicroelectronics
  pack: Keil.STBlueNRG-LP_DFP.3.0.0
  cpu: as above
  output: BLE_SerialPort_Server_Use_OTA_ServiceManager +hex
  AfterMake: fromelf.exe --bin Server_Use_OTA_ServiceManager\Objects\BLE_SerialPort_Server_Use_OTA_ServiceManager.axf --output Server_Use_OTA_ServiceManager\Objects\BLE_SerialPort_Server_Use_OTA_ServiceManager.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: USE_FULL_LL_DRIVER STEVAL_IDB011V1 SERVER=1 CONFIG_DEVICE_BLUENRG_LP CONFIG_HW_SMPS_10uH CONFIG_HW_HSE_TUNE=32 USER_BUTTON=BSP_PUSH1 CONFIG_OTA_USE_SERVICE_MANAGER CONFIG_HW_LS_XTAL BLE_STACK_BASIC_CONF
  c include: as above
  asm misc: --cpreproc
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: BlueNRG_LP.sct
  link misc: --predefine="-DCONFIG_OTA_USE_SERVICE_MANAGER=1 "
